# Add bash dependency for scripts
RDEPENDS:${PN} += "bash" 